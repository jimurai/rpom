# Keil uVision project rpom.uvproj, settings and files
target rpom (ARM-ADS)
  device: EFM32TG210F32 Energy Micro
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0-0x7FFF) CLOCK(32000000) CPUTYPE("Cortex-M3")
  output: rpom
  c flags: Optim=1
  c define: EFM32TG210F32 DEBUG_EFM
  c misc: --c99
  c include: ..\;..\..\..\..\..\CMSIS\Include;..\..\..\..\..\Device\EnergyMicro\EFM32TG\Include;..\..\..\..\..\emlib\inc;..\..\..\drivers;..\..\..\bsp
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group CMSIS
    ../../../../../Device/EnergyMicro/EFM32TG/Source/ARM/: startup_efm32tg.s
    ../../../../../Device/EnergyMicro/EFM32TG/Source/: system_efm32tg.c
  group emlib
    ../../../../../emlib/src/: em_assert.c em_system.c em_cmu.c em_emu.c em_gpio.c em_dac.c em_adc.c em_letimer.c em_usart.c em_opamp.c em_timer.c
  group BSP
    ../../../bsp/: trace.c
  group Source
    ../efm32/: bsp.c comms.c main.c
